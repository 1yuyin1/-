# Keil uVision project TEXT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: TEXT +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LCD.h LCD.c Timer.c Timer.h Delay.c Delay.h DS18B20.c DS18B20.h OneWire.c OneWire.h key.c key.h AT24C02.c AT24C02.h I2C.c I2C.h
